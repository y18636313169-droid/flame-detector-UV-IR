# Keil uVision project fire_source_identification.uvprojx, settings and files
target fire_source_identification (6240000::V6.24::ARMCLANG)
  device: STM32L151RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: fire_source_identification +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xE
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../Code/bsp/inc;../Code/ap/inc;../Code/modules/cmdline;../Code/modules/crc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l151xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c tim.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Core/bsp
    ../Code/bsp/src/: hal_adc.c hal_board.c hal_gpio.c hal_led.c hal_tim.c hal_uart.c ring_buffer.c hal_eeprom.c hal_alarm.c hal_iwdg.c
  group Core/ap
    ../Code/ap/src/: ap_adc.c ap_uart_protocol.c ap_uv.c ap_eeprom.c ap_ir.c
  group Core/modules
    ../Code/modules/cmdline/: cmd.c
    ../Code/modules/crc/: crc16.c
software components: CMSIS:CORE 6.2.0
